options:
  parameters:
    author: t0x1c-v4p0r
    category: Custom
    description: Receives ax.25 packets , display the packets, and converts aprs packet to be send via tcp/ip
    generate_options: no_gui
    id: APRS
    output_language: python
    title: APRS packets for Cesium Flight Tracker
  states: {}

blocks:
- name: Attack
  id: variable
  parameters:
    value: '0.8'
  states: {}
- name: Decay
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: Decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: ax25_aprs2inet_0
  id: ax25_aprs2inet
  parameters:
    debug_level: '2'
    sample_rate: int(samp_rate/4)
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2450'
    low_cutoff_freq: '950'
    samp_rate: samp_rate/Decim
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /dev/fd/1
    type: byte
  states: {}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: detectMarkSpace_0_0
  id: detectMarkSpace
  parameters:
    Frequency: '1200'
    attack: Attack
    decay: Decay
    samp_rate: samp_rate/Decim
  states: {}
- name: detectMarkSpace_1_0
  id: detectMarkSpace
  parameters:
    Frequency: '2200'
    attack: Attack
    decay: Decay
    samp_rate: samp_rate/Decim
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    comment: Change the address to your Cesium flight tracker server's.
    mode: '1'
    port: '3000'
    type: byte
  states: {}

connections:
- [audio_source_0, '0', band_pass_filter_0_0, '0']
- [ax25_aprs2inet_0, '0', blocks_file_sink_0, '0']
- [ax25_aprs2inet_0, '0', network_tcp_sink_0, '0']
- [band_pass_filter_0_0, '0', detectMarkSpace_0_0, '0']
- [band_pass_filter_0_0, '0', detectMarkSpace_1_0, '0']
- [blocks_sub_xx_0_0_0, '0', ax25_aprs2inet_0, '0']
- [detectMarkSpace_0_0, '0', blocks_sub_xx_0_0_0, '0']
- [detectMarkSpace_1_0, '0', blocks_sub_xx_0_0_0, '1']

metadata:
  file_format: 1
